# Keil uVision project display.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C58RD+ STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: display +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\Keil_v5\C51
  group Source Group 1
    ./: main.c dis.c dis.h
