# Keil uVision project develop1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C58RD+ STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: develop1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: dis.c dis.h Ircon.c Ircon.h main.c cycle.c array.h mode3.c mode3.h
